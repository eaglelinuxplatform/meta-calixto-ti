TFA_TI = ""
TFA_TI:k3 = "trusted-firmware-a-calixto.inc"

require ${TFA_TI}



