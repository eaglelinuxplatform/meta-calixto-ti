FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:am62l-stamp-1gb = "file://am62l-stamp-1gb/uEnv-am62l-sk.txt"
SRC_URI:am62l-stamp-2gb = "file://am62l-stamp-2gb/uEnv-am62l-sk.txt"
SRC_URI:am62l-stamp-256mb = "file://am62l-stamp-256mb/uEnv-am62l-sk.txt"
SRC_URI:am62l-stamp-512mb = "file://am62l-stamp-512mb/uEnv-am62l-sk.txt"
